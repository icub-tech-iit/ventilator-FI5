# Keil uVision project demo005.uvprojx, settings and files
target demo-vnt (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: demo002 +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_F7DISCO USE_STM32746G_DISCO EW_USE_EXTERNAL_FLASH=1 EW_BITMAP_PIXEL_SECTION_NAME=.SectionEwResource EW_FONT_PIXEL_SECTION_NAME=.SectionEwResource
  c misc: -Wno-deprecated-register -DEW_SURFACE_ROTATION=0 -DEW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565
  c include: ..\..\stm32hal\api;..\code\iit;..\code\matlab-removed;..\..\stm32f7-bsp\STM32746G-Discovery;..\..\osal\api;..\..\vnt\core;..\..\vnt\os;..\..\vnt\bsp;..\..\vnt\app;..\..\vnt\measure;..\code\controller\controller\controller_ert_rtw;..\code\controller\R2020a\simulink\include;..\..\vnt\tools;..\..\ew\TargetSpecific;..\..\ew\TargetSpecific\Drivers;..\..\ew\app\Source;..\..\ew\app\GeneratedCode;..\..\ew\PlatformPackage\RGB565;..\..\ew\PlatformPackage\RTE;..\..\ew\app\GeneratedCode
  memory RVCT4: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group application
    ../code/iit/: main.cpp app_tCTRL.cpp app_tHMI.cpp app_theController.cpp app_theControllerValidator.cpp
  group matlab-controller
    ../code/controller/controller/controller_ert_rtw/: controller.cpp controller_data.cpp rt_r32zcfcn.cpp
  group stm32f7-bsp
    ../../stm32f7-bsp/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c stm32746g_discovery_qspi.c
  group stm32hal
    ../../stm32hal/lib/: stm32hal.f7disco.v1280.lib
  group irq-handlers
    ../code/iit/: stm32f7xx_it.c
  group startup
    ../code/iit/: startup_stm32f7disco.s
  group osal
    ../../osal/lib/: osal.cm4.dbg.lib
  group vnt-core
    ../../vnt/core/: vnt_core.cpp vnt_core_binary.cpp
  group vnt-os
    ../../vnt/os/: vnt_os.cpp vnt_os_Action.cpp vnt_os_theCallbackManager.cpp vnt_os_theScheduler.cpp vnt_os_theTimerManager.cpp vnt_os_Thread.cpp vnt_os_Timer.cpp
  group vnt-app
    ../../vnt/app/: vnt_app_theLEDmanager.cpp
  group vnt-bsp
    ../../vnt/bsp/: vnt_bsp.cpp vnt_bsp_led.cpp vnt_bsp_button.cpp vnt_bsp_trace.cpp vnt_bsp_watchdog.cpp vnt_bsp_sns_pressure.cpp vnt_bsp_act_valve.cpp
  group vnt-measure
    ../../vnt/measure/: vnt_measure.cpp
  group vnt-bsp-lowlevel
    ../../vnt/bsp/: vnt_bsp_lowlevel.cpp
  group vnt-tools
    ../../vnt/tools/: vnt_tools_Feeder.cpp
  group emwi-target-stm32f7
    ../../ew/TargetSpecific/: ew_bsp_clock.c ew_bsp_console.c ew_bsp_display.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_inout.c ew_bsp_system.c ew_bsp_touch.c
    ../../ew/TargetSpecific/Drivers/: ft5336.c
  group emwi-platform-package
    ../../ew/PlatformPackage/RGB565/: ewextgfx.c libewgfx-m7-keil.lib
    ../../ew/PlatformPackage/RTE/: ewextrte.c libewrte-m7-keil.lib
  group emwi-code
    ../../ew/app/Source/: DeviceDriver.c ewmain.c
  group emwi-generated-code
    ../../ew/app/GeneratedCode/: Application.c Charts.c Climate.c Core.c Effects.c Graphics.c Resources.c Views.c
target STM32746G_Discovery_AXIM-FLASH (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: as above
  output: STM32746G_Discovery_AXIM-FLASH
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;../../STM32Cube_FW_F7_V1.16.0/Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../STM32Cube_FW_F7_V1.16.0/Drivers/STM32F7xx_HAL_Driver/Inc;../../STM32Cube_FW_F7_V1.16.0/Drivers/BSP/STM32746G-Discovery;../../STM32Cube_FW_F7_V1.16.0/Drivers/BSP/Components/Common;../../STM32Cube_FW_F7_V1.16.0/Drivers/BSP/Components/ft5336;../../STM32Cube_FW_F7_V1.16.0/Drivers/BSP/Components/ov9655;../../STM32Cube_FW_F7_V1.16.0/Drivers/BSP/Components/rk043fn48h;../../STM32Cube_FW_F7_V1.16.0/Drivers/BSP/Components/n25q128a;../../STM32Cube_FW_F7_V1.16.0/Drivers/BSP/Components/wm8994;../../../../Utilities/Log;../../../../Utilities/Fonts;../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
