# Keil uVision project demo002.uvprojx, settings and files
target demo-stm32hal (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: demo002 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: USE_STM32HAL STM32HAL_BOARD_F7DISCO
  c include: ..\..\stm32hal\api;..\code\iit;..\code\matlab;..\..\stm32f7-bsp\STM32746G-Discovery
  memory RVCT4: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group stm32f7-bsp
    ../../stm32f7-bsp/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c stm32746g_discovery_qspi.c
  group iit-code
    ../code/iit/: demo-main.cpp stm32f746g_discovery_demo.cpp
  group matlabcode
    ../code/iit/: stm32f746g_discovery_if2cpp.cpp
    ../code/matlab/: Controller.cpp Controller_data.cpp
  group stm32hal
    ../../stm32hal/lib/: stm32hal.f7disco.v1280.lib
  group irq-handlers
    ../code/iit/: stm32f7xx_it.c
  group startup
    ../code/iit/: startup_stm32f7disco.s
target STM32746G_Discovery_AXIM-FLASH (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: as above
  output: STM32746G_Discovery_AXIM-FLASH
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;../../STM32Cube_FW_F7_V1.16.0/Drivers/CMSIS/Device/ST/STM32F7xx/Include;../../STM32Cube_FW_F7_V1.16.0/Drivers/STM32F7xx_HAL_Driver/Inc;../../STM32Cube_FW_F7_V1.16.0/Drivers/BSP/STM32746G-Discovery;../../STM32Cube_FW_F7_V1.16.0/Drivers/BSP/Components/Common;../../STM32Cube_FW_F7_V1.16.0/Drivers/BSP/Components/ft5336;../../STM32Cube_FW_F7_V1.16.0/Drivers/BSP/Components/ov9655;../../STM32Cube_FW_F7_V1.16.0/Drivers/BSP/Components/rk043fn48h;../../STM32Cube_FW_F7_V1.16.0/Drivers/BSP/Components/n25q128a;../../STM32Cube_FW_F7_V1.16.0/Drivers/BSP/Components/wm8994;../../../../Utilities/Log;../../../../Utilities/Fonts;../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.3.0
