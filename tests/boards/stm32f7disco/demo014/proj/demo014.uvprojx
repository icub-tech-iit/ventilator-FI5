# Keil uVision project demo014.uvprojx, settings and files
target demo-vnt (6140000::V6.14::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IROM(0x08000000-0x080FFFFF) IRAM(0x20000000-0x2004FFFF) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: fi5app +hex
  AfterMake: cmd.exe /C copy .\obj\fi5app.hex .\fi5app.hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: notAPP_HMI_disable VNTcfg_FI5 notDRIVER_HAS_INTERNALDEBOUNCE USE_STM32HAL STM32HAL_BOARD_F7DISCO USE_STM32746G_DISCO EW_USE_EXTERNAL_FLASH=1 EW_BITMAP_PIXEL_SECTION_NAME=.SectionEwResource EW_FONT_PIXEL_SECTION_NAME=.SectionEwResource
  c misc: -Wno-deprecated-register -DEW_SURFACE_ROTATION=180 -DEW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565
  c include: ..\..\stm32hal\api;..\code\iit;..\code\matlab-removed;..\..\stm32f7-bsp\STM32746G-Discovery;..\..\osal\api;..\..\vnt\core;..\..\vnt\os;..\..\vnt\bsp;..\..\vnt\app;..\..\vnt\measure;..\code\controller\controller\controller_ert_rtw;..\code\controller\R2020a\simulink\include;..\..\vnt\tools;..\..\ew\TargetSpecific;..\..\ew\TargetSpecific\Drivers;..\..\ew\app\Source;..\..\ew\app\GeneratedCode;..\..\ew\PlatformPackage\RGB565;..\..\ew\PlatformPackage\RTE;..\..\ew\app\GeneratedCode\STM32F746;..\..\..\..\..\drivers;..\code\fsm\FSM0_ert_rtw
  memory RVCT4: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group application
    ../code/iit/: fi5application.cpp fi5app_tCTRL.cpp fi5app_tHMI.cpp fi5app_theController2.cpp
  group matlab-controller
    ../code/controller/controller/controller_ert_rtw/: controller.cpp controller_data.cpp rt_r32zcfcn.cpp rt_nonfinite.cpp rtGetInf.cpp rtGetNaN.cpp
  group matlab-fsm
    ../code/fsm/FSM0_ert_rtw/: FSM0.cpp FSM0_data.cpp
  group stm32f7-bsp
    ../../stm32f7-bsp/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sdram.c stm32746g_discovery_qspi.c
  group stm32hal
    ../../stm32hal/lib/: stm32hal.f7disco.v1280.lib
  group irq-handlers
    ../code/iit/: stm32f7xx_it.c
  group startup
    ../code/iit/: startup_stm32f7disco.s
  group osal
    ../../osal/lib/: osal.cm4.dbg.lib
  group vnt-core
    ../../vnt/core/: vnt_core.cpp vnt_core_binary.cpp
  group vnt-os
    ../../vnt/os/: vnt_os.cpp vnt_os_Action.cpp vnt_os_theCallbackManager.cpp vnt_os_theScheduler.cpp vnt_os_theTimerManager.cpp vnt_os_Thread.cpp vnt_os_Timer.cpp
  group vnt-app
    ../../vnt/app/: vnt_app_theLEDmanager.cpp
  group vnt-bsp
    ../../vnt/bsp/: vnt_bsp.cpp vnt_bsp_led.cpp vnt_bsp_button.cpp vnt_bsp_trace.cpp vnt_bsp_watchdog.cpp
  group vnt-measure
    ../../vnt/measure/: vnt_measure.cpp
  group vnt-bsp-lowlevel
    ../../vnt/bsp/: vnt_bsp_lowlevel.cpp
  group vnt-tools
    ../../vnt/tools/: vnt_tools_Feeder.cpp vnt_tools.cpp
  group emwi-target-stm32f7
    ../../ew/TargetSpecific/: ew_bsp_clock.c ew_bsp_console.c ew_bsp_display.c ew_bsp_event.c ew_bsp_graphics.c ew_bsp_inout.c ew_bsp_system.c ew_bsp_touch.c
    ../../ew/TargetSpecific/Drivers/: ft5336.c
  group emwi-platform-package
    ../../ew/PlatformPackage/RGB565/: ewextgfx.c libewgfx-m7-r180-keil.lib libewgfx-m7-keil.lib
    ../../ew/PlatformPackage/RTE/: ewextrte.c libewrte-m7-keil.lib
  group emwi-code
    ../../ew/app/Source/: DeviceDriver.c ewmain.c
  group emwi-generated-code
    ../../ew/app/GeneratedCode/STM32F746/: Application.c Charts.c Core.c Effects.c Graphics.c Resources.c Templates.c Views.c WidgetSet.c
  group drivers
    ../../../../../drivers/: board_driver.c hsc.c i2c_mux.c mcp23017.c pwm.c zephyr.c analog.c button.c encoder.c buzzer.c
target demo-vnt-no-hmi (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: as above
  output: demo002 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=6 wLevel=3
  c define: TESTRUNTIMEDBG APP_DRV_onlyBTNSGPIO APP_HMI_disable USE_STM32HAL STM32HAL_BOARD_F7DISCO USE_STM32746G_DISCO EW_USE_EXTERNAL_FLASH=1 EW_BITMAP_PIXEL_SECTION_NAME=.SectionEwResource EW_FONT_PIXEL_SECTION_NAME=.SectionEwResource
  c misc: -Wno-deprecated-register -DEW_SURFACE_ROTATION=0 -DEW_FRAME_BUFFER_COLOR_FORMAT=EW_FRAME_BUFFER_COLOR_FORMAT_RGB565
  c include: ..\..\stm32hal\api;..\code\iit;..\code\matlab-removed;..\..\stm32f7-bsp\STM32746G-Discovery;..\..\osal\api;..\..\vnt\core;..\..\vnt\os;..\..\vnt\bsp;..\..\vnt\app;..\..\vnt\measure;..\code\controller\controller\controller_ert_rtw;..\code\controller\R2020a\simulink\include;..\..\vnt\tools;..\..\ew\TargetSpecific;..\..\ew\TargetSpecific\Drivers;..\..\ew\app\Source;..\..\ew\app\GeneratedCode;..\..\ew\PlatformPackage\RGB565;..\..\ew\PlatformPackage\RTE;..\..\ew\app\GeneratedCode;..\..\..\..\..\drivers;..\code\fsm\fsm\FSM0_ert_rtw
  memory RVCT4: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
